# Keil uVision project SimpleClient.uvprojx, settings and files
target SimpleClient (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F756NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: SimpleClient
  c flags: Optim=4
  c define: USE_STM32756G_EVAL USE_IOEXPANDER WOLFSSL_USER_SETTINGS
  c misc: --diag_suppress=68 --diag_suppress=1293
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=68
  group Source
    ./: main.c
  group Documentation
    ./: Abstract.txt
  group Linker Script
    ./: wolfssl-link.sct
  group Configuration
    ./RTE/wolfSSL/: user_settings.h
software components: CMSIS Driver:Ethernet PHY:DP83848C 6.2.0, CMSIS Driver:Flash:M29EW28F128 1.3.0, CMSIS:CORE 5.1.1, CMSIS:RTOS:Keil RTX5 5.3.0, CMSIS:RTOS2:Keil RTX5 5.3.0, Compiler:I/O:File 1.2.1, Compiler:I/O:STDERR 1.2.1, Compiler:I/O:STDIN 1.2.1, Compiler:I/O:STDOUT 1.2.1, Compiler:I/O:TTY 1.2.1, File System:CORE 6.10.1, File System:Drive:Memory Card 6.10.1, Network:CORE 7.9.0, Network:Interface:ETH 7.9.0, Network:Service:DNS Client 7.9.0, Network:Socket:BSD 7.9.0, Network:Socket:TCP 7.9.0, Network:Socket:UDP 7.9.0, Board Support:Drivers:Basic I/O 1.1.0, Board Support:Drivers:I/O 1.1.0, Board Support:Drivers:SDRAM 1.1.0, Board Support:Graphic LCD 1.1.0, Board Support:LED 1.1.0, CMSIS Driver:Ethernet MAC 1.6.0, CMSIS Driver:MCI 1.6.0, Device:STM32Cube Framework:Classic 1.2.6, Device:STM32Cube HAL:ADC 1.2.6, Device:STM32Cube HAL:CRYP 1.2.6, Device:STM32Cube HAL:Common 1.2.6, Device:STM32Cube HAL:Cortex 1.2.6, Device:STM32Cube HAL:DMA 1.2.6, Device:STM32Cube HAL:GPIO 1.2.6, Device:STM32Cube HAL:HASH 1.2.6, Device:STM32Cube HAL:I2C 1.2.6, Device:STM32Cube HAL:LTDC 1.2.6, Device:STM32Cube HAL:PWR 1.2.6, Device:STM32Cube HAL:RCC 1.2.6, Device:STM32Cube HAL:RNG 1.2.6, Device:STM32Cube HAL:SDRAM 1.2.6, Device:STM32Cube HAL:SRAM 1.2.6, Device:STM32Cube HAL:UART 1.2.6, Device:Startup 1.2.2, wolfSSL:wolfCrypt:CORE 3.15.7, wolfSSL:wolfSSL:Core 3.15.7, wolfSSL:wolfSSL:SimpleClient 3.15.7
