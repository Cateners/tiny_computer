# Keil uVision project wolfSSL-Lib.uvprojx, settings and files
target wolfSSL-Lib (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F765NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: wolfSSL (library)
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: MDK_CONF_WOLFLIB WOLFSSL_USER_SETTINGS
  c misc: --diag_suppress=1293
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group Configuration
    ./RTE/wolfSSL/: user_settings.h
  group Documentation
    ./: Abstract.txt
software components: CMSIS Driver:Ethernet PHY:ST802RT1 6.2.0, CMSIS:CORE 5.1.1, CMSIS:RTOS:Keil RTX5 5.3.0, CMSIS:RTOS2:Keil RTX5 5.3.0, Network:CORE 7.9.0, Network:Interface:ETH 7.9.0, Network:Service:DNS Client 7.9.0, Network:Socket:BSD 7.9.0, Network:Socket:TCP 7.9.0, Network:Socket:UDP 7.9.0, CMSIS Driver:Ethernet MAC 1.6.0, Device:STM32Cube Framework:Classic 1.2.6, Device:STM32Cube HAL:Common 1.2.6, Device:STM32Cube HAL:Cortex 1.2.6, Device:STM32Cube HAL:DMA 1.2.6, Device:STM32Cube HAL:ETH 1.2.6, Device:STM32Cube HAL:GPIO 1.2.6, Device:STM32Cube HAL:PWR 1.2.6, Device:STM32Cube HAL:RCC 1.2.6, Device:STM32Cube HAL:SRAM 1.2.6, Device:Startup 1.2.2, wolfSSL:wolfCrypt:CORE 3.15.7, wolfSSL:wolfSSL:Core 3.15.7
